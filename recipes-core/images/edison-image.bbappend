# add gpsd
IMAGE_INSTALL += "gpsd"

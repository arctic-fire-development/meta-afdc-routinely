PACKAGECONFIG_remove = "bluez"
